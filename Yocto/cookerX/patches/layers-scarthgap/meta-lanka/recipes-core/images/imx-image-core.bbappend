
IMAGE_BOOT_FILES += " boot.scr"